# Keil uVision project lab3.uvprojx, settings and files
target stm32L476DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_DISCO_REVC
  c misc: --locale=english
  c include: .\inc;..\STM32Cube_FW_L4_V1.8.0\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\STM32Cube_FW_L4_V1.8.0\Drivers\STM32L4xx_HAL_Driver\Inc;..\STM32Cube_FW_L4_V1.8.0\Drivers\BSP\STM32L476G-Discovery;..\STM32Cube_FW_L4_V1.8.0\Drivers\BSP\Components\Common;..\STM32Cube_FW_L4_V1.8.0\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group src
    ./src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c i2c_at24c64.c
  group inc
    ./inc/: main.h stm32l4xx_hal_conf.h stm32l4xx_it.h i2c_at24c64.h
  group stm32L476
    ../STM32Cube_FW_L4_V1.8.0/Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery_glass_lcd.c stm32l476g_discovery.c
  group HAL_Drivers
    ../STM32Cube_FW_L4_V1.8.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
software components: CMSIS:CORE 5.0.1, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.2.0
